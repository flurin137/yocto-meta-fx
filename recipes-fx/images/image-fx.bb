SUMMARY = "The Qt5 Yocto image based on the rpi-basic-image"
LICENSE = "MIT"

include ${TOPDIR}/../layers/meta-raspberrypi/recipes-core/images/rpi-basic-image.bb
